# Keil uVision project B1001FW.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: B1001FW +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Souce\src;..\Souce\inc
  group Source Group 1
    ./: STARTUP.A51
    ../Souce/src/: main.c pwm.c lcd1602.c uart.c
